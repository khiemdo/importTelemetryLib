# Keil uVision project Nucleo_printf.uvprojx, settings and files
target mbed_DISCO_F469NI (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F469NIHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.7.0
  cpu: IROM(0x08000000,0x200000) IRAM(0x20000000,0x50000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Nucleo_printf
  c flags: Optim=1 OneElfS=1
  c define: TARGET_RTOS_M4_M7,  TARGET_FF_ARDUINO,  __CORTEX_M4,  MBED_BUILD_TIMESTAMP=1457859990.06,  __FPU_PRESENT=1,  TARGET_CORTEX_M,  TARGET_STM32F469NI,  TOOLCHAIN_ARM_MICRO,  TARGET_STM,  TARGET_LIKE_CORTEX_M4,  TARGET_M4,  __MBED__=1,  TARGET_DISCO_F469NI,  TARGET_LIKE_MBED,  TARGET_STM32F4,  TOOLCHAIN_ARM,  ARM_MATH_CM4,  TARGET_STM32F469,  __ASSERT_MSG,
  c misc: --gnu --no_rtti
  c include: .;  telemetry;  telemetry/c_api;  BufferedSerial;  BufferedSerial/Buffer;  mbed;  mbed/TARGET_DISCO_F469NI;  mbed/TARGET_DISCO_F469NI/TARGET_STM;  mbed/TARGET_DISCO_F469NI/TARGET_STM/TARGET_STM32F4;  mbed/TARGET_DISCO_F469NI/TARGET_STM/TARGET_STM32F4/TARGET_DISCO_F469NI;  mbed/TARGET_DISCO_F469NI/TOOLCHAIN_ARM_MICRO
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x50000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: mbed/TARGET_DISCO_F469NI/TOOLCHAIN_ARM_MICRO/stm32f469xx.sct
  link misc: mbed/TARGET_DISCO_F469NI/TOOLCHAIN_ARM_MICRO/stm32f4xx_hal_flash_ramfunc.o
            
              mbed/TARGET_DISCO_F469NI/TOOLCHAIN_ARM_MICRO/board.o
            
              mbed/TARGET_DISCO_F469NI/TOOLCHAIN_ARM_MICRO/cmsis_nvic.o
            
              mbed/TARGET_DISCO_F469NI/TOOLCHAIN_ARM_MICRO/hal_tick.o
            
              mbed/TARGET_DISCO_F469NI/TOOLCHAIN_ARM_MICRO/mbed_overrides.o
            
              mbed/TARGET_DISCO_F469NI/TOOLCHAIN_ARM_MICRO/retarget.o
            
              mbed/TARGET_DISCO_F469NI/TOOLCHAIN_ARM_MICRO/startup_stm32f469xx.o
            
              mbed/TARGET_DISCO_F469NI/TOOLCHAIN_ARM_MICRO/stm32f4xx_hal.o
            
              mbed/TARGET_DISCO_F469NI/TOOLCHAIN_ARM_MICRO/stm32f4xx_hal_adc.o
            
              mbed/TARGET_DISCO_F469NI/TOOLCHAIN_ARM_MICRO/stm32f4xx_hal_adc_ex.o
            
              mbed/TARGET_DISCO_F469NI/TOOLCHAIN_ARM_MICRO/stm32f4xx_hal_can.o
            
              mbed/TARGET_DISCO_F469NI/TOOLCHAIN_ARM_MICRO/stm32f4xx_hal_cec.o
            
              mbed/TARGET_DISCO_F469NI/TOOLCHAIN_ARM_MICRO/stm32f4xx_hal_cortex.o
            
              mbed/TARGET_DISCO_F469NI/TOOLCHAIN_ARM_MICRO/stm32f4xx_hal_crc.o
            
              mbed/TARGET_DISCO_F469NI/TOOLCHAIN_ARM_MICRO/stm32f4xx_hal_cryp.o
            
              mbed/TARGET_DISCO_F469NI/TOOLCHAIN_ARM_MICRO/stm32f4xx_hal_cryp_ex.o
            
              mbed/TARGET_DISCO_F469NI/TOOLCHAIN_ARM_MICRO/stm32f4xx_hal_dac.o
            
              mbed/TARGET_DISCO_F469NI/TOOLCHAIN_ARM_MICRO/stm32f4xx_hal_dac_ex.o
            
              mbed/TARGET_DISCO_F469NI/TOOLCHAIN_ARM_MICRO/stm32f4xx_hal_dcmi.o
            
              mbed/TARGET_DISCO_F469NI/TOOLCHAIN_ARM_MICRO/stm32f4xx_hal_dcmi_ex.o
            
              mbed/TARGET_DISCO_F469NI/TOOLCHAIN_ARM_MICRO/stm32f4xx_hal_dma.o
            
              mbed/TARGET_DISCO_F469NI/TOOLCHAIN_ARM_MICRO/stm32f4xx_hal_dma2d.o
            
              mbed/TARGET_DISCO_F469NI/TOOLCHAIN_ARM_MICRO/stm32f4xx_hal_dma_ex.o
            
              mbed/TARGET_DISCO_F469NI/TOOLCHAIN_ARM_MICRO/stm32f4xx_hal_dsi.o
            
              mbed/TARGET_DISCO_F469NI/TOOLCHAIN_ARM_MICRO/stm32f4xx_hal_eth.o
            
              mbed/TARGET_DISCO_F469NI/TOOLCHAIN_ARM_MICRO/stm32f4xx_hal_flash.o
            
              mbed/TARGET_DISCO_F469NI/TOOLCHAIN_ARM_MICRO/stm32f4xx_hal_flash_ex.o
            
              mbed/TARGET_DISCO_F469NI/TOOLCHAIN_ARM_MICRO/stm32f4xx_hal_fmpi2c_ex.o
            
              mbed/TARGET_DISCO_F469NI/TOOLCHAIN_ARM_MICRO/stm32f4xx_hal_fmpi2c.o
            
              mbed/TARGET_DISCO_F469NI/TOOLCHAIN_ARM_MICRO/stm32f4xx_hal_msp_template.o
            
              mbed/TARGET_DISCO_F469NI/TOOLCHAIN_ARM_MICRO/stm32f4xx_hal_gpio.o
            
              mbed/TARGET_DISCO_F469NI/TOOLCHAIN_ARM_MICRO/stm32f4xx_hal_hash.o
            
              mbed/TARGET_DISCO_F469NI/TOOLCHAIN_ARM_MICRO/stm32f4xx_hal_hash_ex.o
            
              mbed/TARGET_DISCO_F469NI/TOOLCHAIN_ARM_MICRO/stm32f4xx_hal_hcd.o
            
              mbed/TARGET_DISCO_F469NI/TOOLCHAIN_ARM_MICRO/stm32f4xx_hal_i2c.o
            
              mbed/TARGET_DISCO_F469NI/TOOLCHAIN_ARM_MICRO/stm32f4xx_hal_i2c_ex.o
            
              mbed/TARGET_DISCO_F469NI/TOOLCHAIN_ARM_MICRO/stm32f4xx_hal_i2s.o
            
              mbed/TARGET_DISCO_F469NI/TOOLCHAIN_ARM_MICRO/stm32f4xx_hal_i2s_ex.o
            
              mbed/TARGET_DISCO_F469NI/TOOLCHAIN_ARM_MICRO/stm32f4xx_hal_irda.o
            
              mbed/TARGET_DISCO_F469NI/TOOLCHAIN_ARM_MICRO/stm32f4xx_hal_iwdg.o
            
              mbed/TARGET_DISCO_F469NI/TOOLCHAIN_ARM_MICRO/stm32f4xx_hal_lptim.o
            
              mbed/TARGET_DISCO_F469NI/TOOLCHAIN_ARM_MICRO/stm32f4xx_hal_ltdc.o
            
              mbed/TARGET_DISCO_F469NI/TOOLCHAIN_ARM_MICRO/stm32f4xx_hal_ltdc_ex.o
            
              mbed/TARGET_DISCO_F469NI/TOOLCHAIN_ARM_MICRO/stm32f4xx_hal_smartcard.o
            
              mbed/TARGET_DISCO_F469NI/TOOLCHAIN_ARM_MICRO/stm32f4xx_hal_nand.o
            
              mbed/TARGET_DISCO_F469NI/TOOLCHAIN_ARM_MICRO/stm32f4xx_hal_nor.o
            
              mbed/TARGET_DISCO_F469NI/TOOLCHAIN_ARM_MICRO/stm32f4xx_hal_pccard.o
            
              mbed/TARGET_DISCO_F469NI/TOOLCHAIN_ARM_MICRO/stm32f4xx_hal_pcd.o
            
              mbed/TARGET_DISCO_F469NI/TOOLCHAIN_ARM_MICRO/stm32f4xx_hal_pcd_ex.o
            
              mbed/TARGET_DISCO_F469NI/TOOLCHAIN_ARM_MICRO/stm32f4xx_hal_pwr.o
            
              mbed/TARGET_DISCO_F469NI/TOOLCHAIN_ARM_MICRO/stm32f4xx_hal_pwr_ex.o
            
              mbed/TARGET_DISCO_F469NI/TOOLCHAIN_ARM_MICRO/stm32f4xx_hal_qspi.o
            
              mbed/TARGET_DISCO_F469NI/TOOLCHAIN_ARM_MICRO/stm32f4xx_hal_rcc.o
            
              mbed/TARGET_DISCO_F469NI/TOOLCHAIN_ARM_MICRO/stm32f4xx_hal_rcc_ex.o
            
              mbed/TARGET_DISCO_F469NI/TOOLCHAIN_ARM_MICRO/stm32f4xx_hal_rng.o
            
              mbed/TARGET_DISCO_F469NI/TOOLCHAIN_ARM_MICRO/stm32f4xx_hal_rtc.o
            
              mbed/TARGET_DISCO_F469NI/TOOLCHAIN_ARM_MICRO/stm32f4xx_hal_rtc_ex.o
            
              mbed/TARGET_DISCO_F469NI/TOOLCHAIN_ARM_MICRO/stm32f4xx_hal_sai.o
            
              mbed/TARGET_DISCO_F469NI/TOOLCHAIN_ARM_MICRO/stm32f4xx_hal_sai_ex.o
            
              mbed/TARGET_DISCO_F469NI/TOOLCHAIN_ARM_MICRO/stm32f4xx_hal_sd.o
            
              mbed/TARGET_DISCO_F469NI/TOOLCHAIN_ARM_MICRO/stm32f4xx_hal_sdram.o
            
              mbed/TARGET_DISCO_F469NI/TOOLCHAIN_ARM_MICRO/stm32f4xx_hal_spdifrx.o
            
              mbed/TARGET_DISCO_F469NI/TOOLCHAIN_ARM_MICRO/stm32f4xx_hal_spi.o
            
              mbed/TARGET_DISCO_F469NI/TOOLCHAIN_ARM_MICRO/stm32f4xx_hal_sram.o
            
              mbed/TARGET_DISCO_F469NI/TOOLCHAIN_ARM_MICRO/stm32f4xx_hal_tim.o
            
              mbed/TARGET_DISCO_F469NI/TOOLCHAIN_ARM_MICRO/stm32f4xx_hal_tim_ex.o
            
              mbed/TARGET_DISCO_F469NI/TOOLCHAIN_ARM_MICRO/stm32f4xx_hal_uart.o
            
              mbed/TARGET_DISCO_F469NI/TOOLCHAIN_ARM_MICRO/stm32f4xx_hal_usart.o
            
              mbed/TARGET_DISCO_F469NI/TOOLCHAIN_ARM_MICRO/stm32f4xx_hal_wwdg.o
            
              mbed/TARGET_DISCO_F469NI/TOOLCHAIN_ARM_MICRO/stm32f4xx_ll_fmc.o
            
              mbed/TARGET_DISCO_F469NI/TOOLCHAIN_ARM_MICRO/stm32f4xx_ll_fsmc.o
            
              mbed/TARGET_DISCO_F469NI/TOOLCHAIN_ARM_MICRO/stm32f4xx_ll_sdmmc.o
            
              mbed/TARGET_DISCO_F469NI/TOOLCHAIN_ARM_MICRO/stm32f4xx_ll_usb.o
            
              mbed/TARGET_DISCO_F469NI/TOOLCHAIN_ARM_MICRO/sys.o
            
              mbed/TARGET_DISCO_F469NI/TOOLCHAIN_ARM_MICRO/system_stm32f4xx.o
            
              mbed/TARGET_DISCO_F469NI/TOOLCHAIN_ARM_MICRO/mbed.ar
  group src
    ./: main.cpp
    telemetry/: Telemetry.cpp
    telemetry/c_api/: crc16.cpp framing.cpp telemetry_core.cpp telemetry_utils.cpp
    BufferedSerial/: BufferedSerial.cpp
    BufferedSerial/Buffer/: MyBuffer.cpp
